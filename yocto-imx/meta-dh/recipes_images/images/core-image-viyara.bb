DESCRIPTION="Recipe for root images for viyara"

require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL_append="hi-mod"
